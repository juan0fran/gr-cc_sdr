<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>CC_Byte_Synchronizer</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>CC Byte Synchronizer</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>access_code</value></param>
<param><key>label</key><value>access_code</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'11010011100100011101001110010001'</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>cc_sdr_cc_decoder</key>
<param><key>id</key><value>cc_sdr_cc_decoder_0</value></param>
<param><key>plen</key><value>param_packet_len</value></param>
<param><key>has_rs</key><value>True</value></param>
<param><key>has_fec</key><value>False</value></param>
<param><key>has_white</key><value>True</value></param>
</block>
<block>
<key>cc_sdr_fixedlen_packet_synchronizer</key>
<param><key>id</key><value>cc_sdr_fixedlen_packet_synchronizer_0</value></param>
<param><key>plentag</key><value>packet_len</value></param>
<param><key>plen</key><value>(param_packet_len+32)*8</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>synctag</key><value>syncword</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>param_threshold</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>bytes</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_packet_len</value></param>
<param><key>label</key><value>pack_len</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>223</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>param_threshold</value></param>
<param><key>label</key><value>threshold</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>cc_sdr_cc_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cc_sdr_cc_decoder_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>cc_sdr_fixedlen_packet_synchronizer_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0</source_block_id><sink_block_id>cc_sdr_fixedlen_packet_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
