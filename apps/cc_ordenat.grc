<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cc_ordenat</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_rx</value></param>
<param><key>value</key><value>437.35e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_tx</value></param>
<param><key>value</key><value>437.35e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>480e3</value></param>
</block>
<block>
<key>CC_9600_RX</key>
<param><key>id</key><value>CC_9600_RX_0</value></param>
<param><key>man_offset</key><value>0</value></param>
</block>
<block>
<key>CC_9600_TX</key>
<param><key>id</key><value>CC_9600_TX_0</value></param>
</block>
<block>
<key>CC_Byte_Synchronizer</key>
<param><key>id</key><value>CC_Byte_Synchronizer_0</value></param>
<param><key>access_code</key><value>'11010011100100011101001110010001'</value></param>
<param><key>param_packet_len</key><value>223</value></param>
<param><key>param_threshold</key><value>3</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>255</value></param>
<param><key>port</key><value>52004</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>223</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>255</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>255</value></param>
<param><key>port</key><value>52003</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_1</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>223</value></param>
<param><key>port</key><value>52000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>56</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>color1</key><value>("blue", "red")</value></param>
<param><key>label1</key><value>Floor Power</value></param>
<param><key>unit1</key><value>dBm</value></param>
<param><key>color2</key><value>("blue", "red")</value></param>
<param><key>label2</key><value>Band Power</value></param>
<param><key>unit2</key><value>dBm</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>-174</value></param>
<param><key>nconnections</key><value>2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Frequency Shift</value></param>
<param><key>unit1</key><value>Hz</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>-5000</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_amsg_source</key>
<param><key>id</key><value>uhd_amsg_source_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_tx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>77.5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>packet_len</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_rx</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>65</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>usrp_control_pdu_to_pmt</key>
<param><key>id</key><value>usrp_control_pdu_to_pmt_0</value></param>
</block>
<block>
<key>usrp_control_pdu_to_pmt</key>
<param><key>id</key><value>usrp_control_pdu_to_pmt_0_0</value></param>
</block>
<connection><source_block_id>CC_9600_RX_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>CC_9600_RX_0</source_block_id><sink_block_id>CC_Byte_Synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CC_9600_RX_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CC_9600_RX_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CC_9600_TX_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>CC_Byte_Synchronizer_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>CC_9600_TX_0</sink_block_id><source_key>pdus</source_key><sink_key>packet</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0_0</source_block_id><sink_block_id>usrp_control_pdu_to_pmt_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0_0_0</source_block_id><sink_block_id>usrp_control_pdu_to_pmt_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhd_amsg_source_0</source_block_id><sink_block_id>blocks_message_source_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>CC_9600_RX_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_control_pdu_to_pmt_0</source_block_id><sink_block_id>uhd_usrp_source_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>usrp_control_pdu_to_pmt_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>out</source_key><sink_key>command</sink_key></connection>
</flow_graph>
